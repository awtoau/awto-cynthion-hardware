# Repository awtoau/awto-cynthion-hardware (continued)

## KiCad design cynthion.kicad_pcb (continued)

Schematic: power_distribution.kicad_sch, ${TITLE}

Parts:
C40: 0.1uF; C_0402_1005Metric; Part Number CL05A104KA5NNNC
D1, D8: D; D_SOD-123FL; Part Number U1D
D16, D19, D20, D27, D28, D29: 6.2±2%; DFN1006-2; Part Number BZX884-B6V2,315
D17, D21: 5.6±2%; DFN1006-2; Part Number BZX884-B5V6,315
Q1, Q2, Q4, Q5, Q6, Q7: PMOS; Vishay_PowerPAK_SC70-6L_Single; Part Number SIA483ADJ-T1-GE3
Q3, Q8, Q11: 2NPN; SOT-363_SC-70-6; Part Number BC847BS
Q9, Q12: PMOS; SOT-23-3; Part Number YJL3401A
Q10, Q13, Q14, Q15: 2PNP; SOT-363_SC-70-6; Part Number BC857BS
R1, R2, R42, R59: 0.02±1%; R_0603_1608Metric_Current_Sense; Part Number ERJ-3BWFR020V
R3, R47, R48, R49, R60, R61, R69, R70, R76, R77: 33k; R_0402_1005Metric; Part Number ERJ-2GEJ333X
R40, R63, R65, R71, R78, R83, R84, R88: 2.2k; R_0402_1005Metric; Part Number RC0402JR-072K2L
R41, R64, R66, R72, R79, R85, R86, R89: 10k; R_0402_1005Metric; Part Number RC0402JR-0710KL
R62, R90, R91, R92, R93, R94, R95, R96, R120: 100k; R_0402_1005Metric; Part Number ERJ-2GEJ104X
R67, R73, R74, R80: 18.7k±1%; R_0402_1005Metric; Part Number ERJ-2RKF1872X
R68, R75: 820k; R_0402_1005Metric; Part Number RC0402JR-07820KL
R87: 5.1k; R_0402_1005Metric; Part Number RC0402JR-075K1L
R103, R112, R113, R114, R115, R116: 0; R_0402_1005Metric; Part Number RC0402FR-070RL
TP49: TestPoint; TestPoint_Pad_D1.0mm
U1: PAC1954; QFN-16-1EP_3x3mm_P0.5mm_EP1.45x1.45mm; Part Number PAC1954T-E/4MX

Connections:
+3V3: C40.1, R83.1, R84.1, R85.1, R86.1, R87.1, U1.2 (VDD); also elsewhere on the board
+5V: D1.1 (K), D8.1 (K), D19.1 (K), TP49.1 (1_1); also elsewhere on the board
/FPGA Banks 0 and 1/MON.GPIO: R86.2, U1.15 (GPIO/~ALERT2); also elsewhere on the board
/FPGA Banks 0 and 1/MON.SCL: R83.2, U1.4 (SCL); also elsewhere on the board
/FPGA Banks 0 and 1/MON.SDA: R84.2, U1.5 (SDA); also elsewhere on the board
/FPGA Banks 0 and 1/MON.SLOW: R85.2, U1.1 (SLOW/~ALERT); also elsewhere on the board
/FPGA Banks 0 and 1/MON.~PWRDN: R87.2, U1.16 (~PWRDN); also elsewhere on the board
/FPGA Banks 2 and 3/~AUX_VBUS_IN_EN: R78.2; also elsewhere on the board
/FPGA Banks 2 and 3/~CONTROL_VBUS_IN_EN: R71.2; also elsewhere on the board
/FPGA Banks 6 and 7/AUX_VBUS_EN: R63.2; also elsewhere on the board
/FPGA Banks 6 and 7/CONTROL_VBUS_EN: R40.2; also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_A_DISCHARGE: R88.2; also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_C_VBUS_EN: R65.2; also elsewhere on the board
/Power Distribution and Monitoring/~POWER_GOOD: R103.2, R112.2, R113.2, R114.2, R115.2, R116.2; also elsewhere on the board
AUX_SENSE+: R42.3, U1.8 (SENSE3+)
AUX_SENSE-: R42.2, U1.7 (SENSE3-)
AUX_VBUS: R42.4; also elsewhere on the board
AUX_VBUS_IN: D20.1 (K), Q4.1 (D), Q10.4 (E2), Q12.2 (S), R42.1, R74.1, R75.1; also elsewhere on the board
CONTROL_SENSE+: R1.2, U1.10 (SENSE4+)
CONTROL_SENSE-: R1.3, U1.9 (SENSE4-)
CONTROL_VBUS: R1.1; also elsewhere on the board
CONTROL_VBUS_IN: D16.1 (K), Q1.1 (D), Q9.2 (S), Q10.1 (E1), R1.4, R67.1, R68.1; also elsewhere on the board
GND: C40.2, D19.2 (A), R41.2, R64.2, R66.2, R70.2, R72.2, R73.2, R77.2, R79.2, R80.2, R89.2, R90.1, R91.1, R94.1, R95.1, R96.1, R120.1, U1.3 (GND), U1.6 (ADDRSEL), U1.17 (GND); also elsewhere on the board
unnamed: D1.2 (A), Q12.3 (D)
unnamed: D8.2 (A), Q9.3 (D)
unnamed: D16.2 (A), Q9.1 (G), Q10.6 (C1), R68.2, R70.1
unnamed: D17.2 (A), R73.1
unnamed: D17.1 (K), R47.2, R67.2, R69.1
unnamed: D20.2 (A), Q10.3 (C2), Q12.1 (G), R75.2, R77.1
unnamed: D21.2 (A), R80.1
unnamed: D21.1 (K), R48.2, R74.2, R76.1
unnamed: D27.2 (A), Q1.3 (G), Q2.3 (G), Q13.6 (C1), R90.2
unnamed: D27.1 (K), Q1.4 (S), Q2.4 (S), Q13.1 (E1), Q13.4 (E2), R3.1
unnamed: D28.2 (A), Q4.3 (G), Q5.3 (G), Q14.6 (C1), R94.2
unnamed: D28.1 (K), Q4.4 (S), Q5.4 (S), Q14.1 (E1), Q14.4 (E2), R60.1
unnamed: D29.2 (A), Q6.3 (G), Q7.3 (G), Q15.6 (C1), R96.2
unnamed: D29.1 (K), Q6.4 (S), Q7.4 (S), Q15.1 (E1), Q15.4 (E2), R61.1
unnamed: Q3.2 (B1), R40.1, R41.1
unnamed: Q3.6 (C1), R3.2, R62.1
unnamed: Q3.1 (E1), R112.1
unnamed: Q3.5 (B2), R63.1, R64.1
unnamed: Q3.3 (C2), R60.2, R92.1
unnamed: Q3.4 (E2), R115.1
unnamed: Q8.2 (B1), R65.1, R66.1
unnamed: Q8.6 (C1), R61.2, R93.1
unnamed: Q8.1 (E1), R114.1
unnamed: Q8.5 (B2), R88.1, R89.1
unnamed: Q8.3 (C2), R49.2
unnamed: Q8.4 (E2), R103.1
unnamed: Q10.2 (B1), R47.1
unnamed: Q10.5 (B2), R48.1
unnamed: Q11.2 (B1), R71.1, R72.1
unnamed: Q11.6 (C1), R69.2
unnamed: Q11.1 (E1), R113.1
unnamed: Q11.5 (B2), R78.1, R79.1
unnamed: Q11.3 (C2), R76.2
unnamed: Q11.4 (E2), R116.1
unnamed: Q13.2 (B1), Q13.3 (C2), R91.2
unnamed: Q13.5 (B2), R62.2
unnamed: Q14.2 (B1), Q14.3 (C2), R95.2
unnamed: Q14.5 (B2), R92.2
unnamed: Q15.2 (B1), Q15.3 (C2), R120.2
unnamed: Q15.5 (B2), R93.2
TARGET_A_SENSE+: R2.3, U1.11 (SENSE1+)
TARGET_A_SENSE-: R2.2, U1.12 (SENSE1-)
TARGET_A_VBUS_IN: Q2.1 (D), Q5.1 (D), Q6.1 (D), R2.1, R49.1
TARGET_C_SENSE+: R59.3, U1.13 (SENSE2+)
TARGET_C_SENSE-: R59.2, U1.14 (SENSE2-)
TARGET_C_VBUS: R59.4; also elsewhere on the board
TARGET_C_VBUS_IN: Q7.1 (D), R59.1; also elsewhere on the board

Notes on the sheet:
VBUS Voltage and Current Monitoring
overvoltage shut-off threshold: 5.5-6.0 V prevents power input on an individual port without disabling pass-through
CONTROL_VBUS working voltage: 4.4 to 5.5 V absolute max: 30 V
TARGET_C_VBUS working voltage: 4.4 to 21 V absolute max: 30 V
VBUS Pass-Through
The FPGA can disable either power input. Overvoltage protection cannot be disabled.
AUX_VBUS working voltage: 4.4 to 21 V if used for power input: 4.4 to 5.5 V absolute max: 30 V
Power Input
TARGET_A_VBUS working voltage: 4.4 to 21 V absolute max: 30 V

Schematic: bank2_3.kicad_sch, ${TITLE}

Parts:
IC1: ECP5-BGA256; lattice_cabga256; Part Number LFE5U-12F-6BG256C

Connections:
+3V3: IC1.F12 (PR8D), IC1.H11 (VCCIO2_1), IC1.J11 (VCCIO2_2), IC1.J12 (PR17D), IC1.K11 (VCCIO3_1), IC1.K12 (PR29B), IC1.L11 (VCCIO3_2), IC1.L12 (PR29D), IC1.M11 (PR47A), IC1.N13 (PR38A), IC1.P11 (PR47C), IC1.P12 (PR47D), IC1.P13 (PR41A); also elsewhere on the board
/AUX Port/AUX_PHY.CLK: IC1.D16 (PR8A); also elsewhere on the board
/AUX Port/AUX_PHY.DATA0: IC1.F16 (PR14A); also elsewhere on the board
/AUX Port/AUX_PHY.DATA1: IC1.G15 (PR14B); also elsewhere on the board
/AUX Port/AUX_PHY.DATA2: IC1.G16 (PR20A); also elsewhere on the board
/AUX Port/AUX_PHY.DATA3: IC1.H15 (PR20B); also elsewhere on the board
/AUX Port/AUX_PHY.DATA4: IC1.J15 (PR23B); also elsewhere on the board
/AUX Port/AUX_PHY.DATA5: IC1.J16 (PR23A); also elsewhere on the board
/AUX Port/AUX_PHY.DATA6: IC1.K15 (PR23D); also elsewhere on the board
/AUX Port/AUX_PHY.DATA7: IC1.K16 (PR23C); also elsewhere on the board
/AUX Port/AUX_PHY.DIR: IC1.E16 (PR11D); also elsewhere on the board
/AUX Port/AUX_PHY.NXT: IC1.F15 (PR11C); also elsewhere on the board
/AUX Port/AUX_PHY.STP: IC1.E15 (PR8B); also elsewhere on the board
/AUX Port/AUX_PHY.~RESET: IC1.J13 (PR17C); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SBU1S: IC1.H13 (PR17B); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SBU2S: IC1.K14 (PR20D); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SCL: IC1.H12 (PR17A); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SDA: IC1.G14 (PR14C); also elsewhere on the board
/AUX Port/AUX_TYPE_C.~FAULT: IC1.J14 (PR20C); also elsewhere on the board
/AUX Port/AUX_TYPE_C.~INT: IC1.H14 (PR14D); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.CLK: IC1.L14 (PR32C); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA0: IC1.N16 (PR32A); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA1: IC1.N14 (PR35D); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA2: IC1.P16 (PR35A); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA3: IC1.P15 (PR32B); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA4: IC1.R16 (PR35B); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA5: IC1.R15 (PR38C); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA6: IC1.T15 (PR38D); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA7: IC1.P14 (PR38B); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DIR: IC1.M16 (PR26C); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.NXT: IC1.M15 (PR26D); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.STP: IC1.L15 (PR26B); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.~RESET: IC1.L16 (PR26A); also elsewhere on the board
/Debugger/FPGA_JTAG.TDI: IC1.R14 (PR41B); also elsewhere on the board
/Debugger/FPGA_JTAG.TMS: IC1.T14 (PR41D); also elsewhere on the board
/Expansion Interfaces/MEZZANINE8: IC1.D14 (PR2D); also elsewhere on the board
/Expansion Interfaces/MEZZANINE9: IC1.C14 (PR2C); also elsewhere on the board
/Expansion Interfaces/MEZZANINE10: IC1.F14 (PR5D); also elsewhere on the board
/Expansion Interfaces/MEZZANINE11: IC1.E14 (PR5C); also elsewhere on the board
/Expansion Interfaces/MEZZANINE12: IC1.G13 (PR11B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE13: IC1.G12 (PR11A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE18: IC1.C16 (PR5A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE19: IC1.C15 (PR5B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE20: IC1.B16 (PR2A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE21: IC1.B15 (PR2B); also elsewhere on the board
/FPGA Bank 8 and Configuration Flash/~FPGA_SELF_PROGRAM: IC1.T13 (PR44B); also elsewhere on the board
/FPGA Banks 2 and 3/~AUX_VBUS_IN_EN: IC1.L13 (PR29C); also elsewhere on the board
/FPGA Banks 2 and 3/~BTN_USER: IC1.M14 (PR32D); also elsewhere on the board
/FPGA Banks 2 and 3/~CONTROL_VBUS_IN_EN: IC1.K13 (PR29A); also elsewhere on the board
GND: IC1.F13 (PR8C), IC1.M12 (PR44C), IC1.M13 (PR35C), IC1.N11 (PR47B), IC1.N12 (PR44D); also elsewhere on the board

Notes on the sheet:
UART RX/TX pins shared with JTAG

Schematic: expansion.kicad_sch, ${TITLE}

Parts:
C74: 1uF; C_0402_1005Metric; Part Number CL05A105MQ5NNNC
J5: MEZZANINE; Amphenol_10132798-03; Part Number 10132798-031100LF
J7: PMOD_A; PinSocket_2x06_P2.54mm_PMOD; Part Number DW254W-22-12-85
J8: PMOD_B; PinSocket_2x06_P2.54mm_PMOD; Part Number DW254W-22-12-85
RN1, RN2, RN3, RN4: 33; R_Array_Convex_4x0402; Part Number YC124-JR-0733RL

Connections:
+3V3: C74.1, J5.15, J5.16, J7.6, J7.12, J8.6, J8.12; also elsewhere on the board
/Expansion Interfaces/A1: J7.1, RN1.8 (R1.2)
/Expansion Interfaces/A2: J7.2, RN1.7 (R2.2)
/Expansion Interfaces/A3: J7.3, RN2.6 (R3.2)
/Expansion Interfaces/A4: J7.4, RN2.8 (R1.2)
/Expansion Interfaces/A7: J7.7, RN1.5 (R4.2)
/Expansion Interfaces/A8: J7.8, RN1.6 (R3.2)
/Expansion Interfaces/A9: J7.9, RN2.5 (R4.2)
/Expansion Interfaces/A10: J7.10, RN2.7 (R2.2)
/Expansion Interfaces/B1: J8.1, RN4.5 (R4.2)
/Expansion Interfaces/B2: J8.2, RN4.7 (R2.2)
/Expansion Interfaces/B3: J8.3, RN3.5 (R4.2)
/Expansion Interfaces/B4: J8.4, RN3.7 (R2.2)
/Expansion Interfaces/B7: J8.7, RN4.6 (R3.2)
/Expansion Interfaces/B8: J8.8, RN4.8 (R1.2)
/Expansion Interfaces/B9: J8.9, RN3.6 (R3.2)
/Expansion Interfaces/B10: J8.10, RN3.8 (R1.2)
/Expansion Interfaces/MEZZANINE3: J5.3; also elsewhere on the board
/Expansion Interfaces/MEZZANINE4: J5.4; also elsewhere on the board
/Expansion Interfaces/MEZZANINE5: J5.5; also elsewhere on the board
/Expansion Interfaces/MEZZANINE6: J5.6; also elsewhere on the board
/Expansion Interfaces/MEZZANINE7: J5.7; also elsewhere on the board
/Expansion Interfaces/MEZZANINE8: J5.8; also elsewhere on the board
/Expansion Interfaces/MEZZANINE9: J5.9; also elsewhere on the board
/Expansion Interfaces/MEZZANINE10: J5.10; also elsewhere on the board
/Expansion Interfaces/MEZZANINE11: J5.11; also elsewhere on the board
/Expansion Interfaces/MEZZANINE12: J5.12; also elsewhere on the board
/Expansion Interfaces/MEZZANINE13: J5.13; also elsewhere on the board
/Expansion Interfaces/MEZZANINE18: J5.18; also elsewhere on the board
/Expansion Interfaces/MEZZANINE19: J5.19; also elsewhere on the board
/Expansion Interfaces/MEZZANINE20: J5.20; also elsewhere on the board
/Expansion Interfaces/MEZZANINE21: J5.21; also elsewhere on the board
/Expansion Interfaces/MEZZANINE22: J5.22; also elsewhere on the board
/Expansion Interfaces/MEZZANINE23: J5.23; also elsewhere on the board
/Expansion Interfaces/MEZZANINE24: J5.24; also elsewhere on the board
/Expansion Interfaces/MEZZANINE25: J5.25; also elsewhere on the board
/Expansion Interfaces/MEZZANINE26: J5.26; also elsewhere on the board
/Expansion Interfaces/MEZZANINE27: J5.27; also elsewhere on the board
/Expansion Interfaces/MEZZANINE28: J5.28; also elsewhere on the board
/Expansion Interfaces/PMOD_A1: RN1.1 (R1.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A2: RN1.2 (R2.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A3: RN2.3 (R3.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A4: RN2.1 (R1.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A7: RN1.4 (R4.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A8: RN1.3 (R3.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A9: RN2.4 (R4.1); also elsewhere on the board
/Expansion Interfaces/PMOD_A10: RN2.2 (R2.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B1: RN4.4 (R4.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B2: RN4.2 (R2.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B3: RN3.4 (R4.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B4: RN3.2 (R2.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B7: RN4.3 (R3.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B8: RN4.1 (R1.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B9: RN3.3 (R3.1); also elsewhere on the board
/Expansion Interfaces/PMOD_B10: RN3.1 (R1.1); also elsewhere on the board
GND: C74.2, J5.2, J5.14, J5.17, J5.29, J5.MP (MountPin), J7.5, J7.11, J8.5, J8.11; also elsewhere on the board

Notes on the sheet:
Pmod
Mezzanine

Schematic: indicators_buttons.kicad_sch, ${TITLE}

Parts:
C76, C78: 1uF; C_0402_1005Metric; Part Number CL05A105MQ5NNNC
D2: RED; LED_0603_1608Metric; Part Number OSR50603C1E
D3: ORANGE; LED_0603_1608Metric; Part Number E6C0603SEAC1UDA
D4: YELLOW; LED_0603_1608Metric; Part Number E6C0603UYAC1UDA
D5: GREEN; LED_0603_1608Metric; Part Number ORH-G36G
D6: BLUE; LED_0603_1608Metric; Part Number ORH-B36G
D7: PURPLE; LED_0603_1608Metric; Part Number OSVX0603C1E
D10, D14: ICE BLUE; LED_0603_1608Metric; Part Number MHT192WDT-ICE
D11, D13: PINK; LED_0603_1608Metric; Part Number OSK40603C1E
D12: WHITE; LED_0603_1608Metric; Part Number ORH-W46G
R7, R11: 5.1k; R_0402_1005Metric; Part Number RC0402JR-075K1L
R8, R9, R10, R30, R31: 2.2k; R_0402_1005Metric; Part Number RC0402JR-072K2L
R26, R27, R28: 1k; R_0402_1005Metric; Part Number RC0402JR-071KL
R29, R106: 10k; R_0402_1005Metric; Part Number RC0402JR-0710KL
R101: 8.06k±1%; R_0402_1005Metric; Part Number ERJ-2RKF8061X
R104: 18.7k±1%; R_0402_1005Metric; Part Number ERJ-2RKF1872X
R107: 33k; R_0402_1005Metric; Part Number ERJ-2GEJ333X
SW1: BTN_PROGRAM; SW_Tactile_SPST_Angled_TC-1109DE-B-F; Part Number TC-1109DE-B-F
SW2: BTN_RESET; SW_Tactile_SPST_Angled_TC-1109DE-B-F; Part Number TC-1109DE-B-F
SW3: BTN_USER; SW_Tactile_SPST_Angled_TC-1109DE-B-F; Part Number TC-1109DE-B-F
TP15, TP31, TP32, TP38, TP39, TP41, TP43, TP47, TP52, TP53, TP54, TP55: TestPoint; TestPoint_Pad_D1.0mm

Connections:
+3V3: D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), R7.1, R8.1, R9.1, R10.1, R11.1, R101.1, R106.1; also elsewhere on the board
/Debugger/LED10: D10.1 (K); also elsewhere on the board
/Debugger/LED11: D11.1 (K); also elsewhere on the board
/Debugger/LED12: D12.1 (K); also elsewhere on the board
/Debugger/LED13: D13.1 (K); also elsewhere on the board
/Debugger/LED14: D14.1 (K); also elsewhere on the board
/Debugger/~BTN_PROGRAM: C76.1, R104.1; also elsewhere on the board
/Debugger/~BTN_RESET: SW2.1; also elsewhere on the board
/FPGA Banks 0 and 1/LED0: R31.2; also elsewhere on the board
/FPGA Banks 0 and 1/LED1: R30.2; also elsewhere on the board
/FPGA Banks 0 and 1/LED2: R29.2; also elsewhere on the board
/FPGA Banks 0 and 1/LED3: R28.2; also elsewhere on the board
/FPGA Banks 0 and 1/LED4: R27.2; also elsewhere on the board
/FPGA Banks 0 and 1/LED5: R26.2; also elsewhere on the board
/FPGA Banks 2 and 3/~BTN_USER: C78.1, R107.1; also elsewhere on the board
GND: C76.2, C78.2, SW1.2, SW1.3 (SHIELD_3), SW2.2, SW2.3 (SHIELD_3), SW3.2, SW3.3 (SHIELD_3); also elsewhere on the board
unnamed: D2.1 (K), R26.1, TP43.1 (1_1)
unnamed: D3.1 (K), R27.1, TP47.1 (1_1)
unnamed: D4.1 (K), R28.1, TP52.1 (1_1)
unnamed: D5.1 (K), R29.1, TP53.1 (1_1)
unnamed: D6.1 (K), R30.1, TP54.1 (1_1)
unnamed: D7.1 (K), R31.1, TP55.1 (1_1)
unnamed: D10.2 (A), R7.2, TP31.1 (1_1)
unnamed: D11.2 (A), R8.2, TP32.1 (1_1)
unnamed: D12.2 (A), R9.2, TP38.1 (1_1)
unnamed: D13.2 (A), R10.2, TP39.1 (1_1)
unnamed: D14.2 (A), R11.2, TP41.1 (1_1)
unnamed: R101.2, R104.2, SW1.1, TP15.1 (1_1)
unnamed: R106.2, R107.2, SW3.1

Notes on the sheet:
FPGA Button
Debugger Buttons
FPGA LEDs 5-0
Debugger LEDs A-E

Schematic: bank0_1.kicad_sch, ${TITLE}

Parts:
IC1: ECP5-BGA256; lattice_cabga256; Part Number LFE5U-12F-6BG256C

Connections:
+3V3: IC1.D10 (PT47A), IC1.E6 (PT20A), IC1.E7 (PT24A), IC1.E10 (PT47B), IC1.E11 (PT51B), IC1.F6 (VCCIO0_1), IC1.F7 (VCCIO0_2), IC1.F10 (VCCIO1_1), IC1.F11 (VCCIO1_2); also elsewhere on the board
/Clock and Miscellaneous/CLOCK_60MHZ: IC1.A8 (PT29B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE3: IC1.B8 (PT35B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE4: IC1.A9 (PT42A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE5: IC1.B10 (PT44A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE6: IC1.A10 (PT42B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE7: IC1.B11 (PT49A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE22: IC1.A14 (PT65B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE23: IC1.B13 (PT60A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE24: IC1.A13 (PT65A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE25: IC1.D13 (PT62A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE26: IC1.A12 (PT53B); also elsewhere on the board
/Expansion Interfaces/MEZZANINE27: IC1.B12 (PT56A); also elsewhere on the board
/Expansion Interfaces/MEZZANINE28: IC1.A11 (PT53A); also elsewhere on the board
/Expansion Interfaces/PMOD_A1: IC1.C9 (PT38B); also elsewhere on the board
/Expansion Interfaces/PMOD_A2: IC1.B9 (PT38A); also elsewhere on the board
/Expansion Interfaces/PMOD_A3: IC1.D11 (PT51A); also elsewhere on the board
/Expansion Interfaces/PMOD_A4: IC1.C12 (PT56B); also elsewhere on the board
/Expansion Interfaces/PMOD_A7: IC1.C8 (PT35A); also elsewhere on the board
/Expansion Interfaces/PMOD_A8: IC1.D8 (PT33B); also elsewhere on the board
/Expansion Interfaces/PMOD_A9: IC1.D9 (PT40A); also elsewhere on the board
/Expansion Interfaces/PMOD_A10: IC1.C10 (PT44B); also elsewhere on the board
/Expansion Interfaces/PMOD_B1: IC1.B4 (PT11B); also elsewhere on the board
/Expansion Interfaces/PMOD_B2: IC1.B5 (PT15B); also elsewhere on the board
/Expansion Interfaces/PMOD_B3: IC1.B6 (PT22B); also elsewhere on the board
/Expansion Interfaces/PMOD_B4: IC1.B7 (PT27B); also elsewhere on the board
/Expansion Interfaces/PMOD_B7: IC1.C5 (PT15A); also elsewhere on the board
/Expansion Interfaces/PMOD_B8: IC1.A5 (PT18A); also elsewhere on the board
/Expansion Interfaces/PMOD_B9: IC1.A6 (PT18B); also elsewhere on the board
/Expansion Interfaces/PMOD_B10: IC1.A7 (PT29A); also elsewhere on the board
/FPGA Banks 0 and 1/LED0: IC1.E13 (PT62B); also elsewhere on the board
/FPGA Banks 0 and 1/LED1: IC1.C13 (PT60B); also elsewhere on the board
/FPGA Banks 0 and 1/LED2: IC1.B14 (PT67A); also elsewhere on the board
/FPGA Banks 0 and 1/LED3: IC1.A15 (PT67B); also elsewhere on the board
/FPGA Banks 0 and 1/LED4: IC1.D12 (PT58A); also elsewhere on the board
/FPGA Banks 0 and 1/LED5: IC1.C11 (PT49B); also elsewhere on the board
/FPGA Banks 0 and 1/MON.GPIO: IC1.D6 (PT20B); also elsewhere on the board
/FPGA Banks 0 and 1/MON.SCL: IC1.D7 (PT24B); also elsewhere on the board
/FPGA Banks 0 and 1/MON.SDA: IC1.C7 (PT27A); also elsewhere on the board
/FPGA Banks 0 and 1/MON.SLOW: IC1.C6 (PT22A); also elsewhere on the board
/FPGA Banks 0 and 1/MON.~PWRDN: IC1.D5 (PT13B); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SBU1S: IC1.A2 (PT4A); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SBU2S: IC1.E4 (PT9A); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SCL: IC1.A4 (PT6B); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SDA: IC1.C4 (PT11A); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.~FAULT: IC1.D4 (PT9B); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.~INT: IC1.A3 (PT6A); also elsewhere on the board
GND: IC1.E5 (PT13A), IC1.E8 (PT33A), IC1.E9 (PT40B), IC1.E12 (PT58B); also elsewhere on the board

Schematic: bank8_configuration.kicad_sch, ${TITLE}

Parts:
C35: 0.1uF; C_0402_1005Metric; Part Number CL05A104KA5NNNC
IC1: ECP5-BGA256; lattice_cabga256; Part Number LFE5U-12F-6BG256C
R5: 2.2k; R_0402_1005Metric; Part Number RC0402JR-072K2L
R6, R13, R102, R109, R110: 5.1k; R_0402_1005Metric; Part Number RC0402JR-075K1L
R12, R14: 330; R_0402_1005Metric; Part Number RC0402FR-13330RL
TP10, TP11, TP12, TP14, TP21, TP22, TP23, TP24: TestPoint; TestPoint_Pad_D1.0mm
U7: W25Q32JVSS; SOIC-8_5.23x5.23mm_P1.27mm; Part Number W25Q32JVSSIQ

Connections:
+3V3: C35.1, IC1.L6 (VCCIO8), IC1.R6 (D6/PB4B), R6.1, R13.2, R109.1, R110.1, U7.8 (VCC); also elsewhere on the board
/Debugger/FPGA_ADV: IC1.T6 (D7/PB4A); also elsewhere on the board
/Debugger/FPGA_CONFIG.DONE: IC1.P9 (DONE), TP12.1 (1_1); also elsewhere on the board
/Debugger/FPGA_CONFIG.~INIT: IC1.T9 (~INIT), R102.1; also elsewhere on the board
/Debugger/FPGA_CONFIG.~PROGRAM: IC1.R9 (~PROGRAM), R5.1, R6.2, TP14.1 (1_1); also elsewhere on the board
/Debugger/FPGA_JTAG.TCK: IC1.T10 (TCK), TP21.1 (1_1); also elsewhere on the board
/Debugger/FPGA_JTAG.TDI: IC1.R11 (TDI), TP24.1 (1_1); also elsewhere on the board
/Debugger/FPGA_JTAG.TDO: IC1.M10 (TDO), TP23.1 (1_1); also elsewhere on the board
/Debugger/FPGA_JTAG.TMS: IC1.T11 (TMS), TP22.1 (1_1); also elsewhere on the board
/FPGA Bank 8 and Configuration Flash/FPGA_CFG0: IC1.N10 (CFG0), R12.1
/FPGA Bank 8 and Configuration Flash/FPGA_CFG1: IC1.P10 (CFG1), R13.1
/FPGA Bank 8 and Configuration Flash/FPGA_CFG2: IC1.R10 (CFG2), R14.1
/FPGA Bank 8 and Configuration Flash/FPGA_FLASH_CLK: IC1.N9 (MCLK/CCLK), R109.2, TP10.1 (1_1), U7.6 (CLK)
/FPGA Bank 8 and Configuration Flash/IO0: IC1.T8 (D0/PICO/IO0/PB11B), U7.5 (DI(IO0))
/FPGA Bank 8 and Configuration Flash/IO1: IC1.T7 (D1/POCI/IO1/PB11A), U7.2 (DO(IO1))
/FPGA Bank 8 and Configuration Flash/IO2: IC1.M7 (D2/IO2/PB9B), U7.3 (IO2)
/FPGA Bank 8 and Configuration Flash/IO3: IC1.N7 (D3/IO3/PB9A), U7.7 (IO3)
/FPGA Bank 8 and Configuration Flash/~CS: IC1.N8 (~HOLD/DI/BUSY/~CSSPI/PB15A), R110.2, TP11.1 (1_1), U7.1 (~CS)
/FPGA Bank 8 and Configuration Flash/~FPGA_SELF_PROGRAM: R5.2; also elsewhere on the board
GND: C35.2, R12.2, R14.2, R102.2, U7.4 (GND); also elsewhere on the board

Notes on the sheet:
By default, select MSPI mode, so the ECP5 will self-configure from flash.
FPGA_ADV is a unidirectional UART for the FPGA to advertise status or requests to the microcontroller.
R5 and R6 allow FPGA to trigger its own programming

Schematic: usb_phy.kicad_sch, ${TITLE}

Parts:
C36, C37: 1uF; C_0402_1005Metric; Part Number CL05A105MQ5NNNC
C38, C39: 0.1uF; C_0402_1005Metric; Part Number CL05A104KA5NNNC
R16: 8.06k±1%; R_0402_1005Metric; Part Number ERJ-2RKF8061X
R17: 20k; R_0402_1005Metric; Part Number RC0402JR-0720KL
R22: 10k; R_0402_1005Metric; Part Number RC0402JR-0710KL
RN5, RN6, RN7: 0; R_Array_Convex_4x0402; Part Number YC124-JR-070RL
TP17, TP26: TestPoint; TestPoint_Pad_D1.0mm
U8: USB3343-CP; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm; Part Number USB3343-CP

Connections:
+3V3: C36.1, C38.1, C39.1, TP26.1 (1_1), U8.2 (CLKOUT), U8.9 (VDDIO), U8.15 (VDD33), U8.16 (VBAT), U8.18 (ID); also elsewhere on the board
/CONTROL Port/CONTROL PHY/CLK: RN5.8 (R1.2), U8.21 (REFCLK/XI)
/CONTROL Port/CONTROL PHY/DATA0: RN6.8 (R1.2), U8.4 (DATA0)
/CONTROL Port/CONTROL PHY/DATA1: RN6.7 (R2.2), U8.5 (DATA1)
/CONTROL Port/CONTROL PHY/DATA2: RN6.6 (R3.2), U8.6 (DATA2)
/CONTROL Port/CONTROL PHY/DATA3: RN6.5 (R4.2), U8.7 (DATA3)
/CONTROL Port/CONTROL PHY/DATA4: RN7.8 (R1.2), U8.8 (DATA4)
/CONTROL Port/CONTROL PHY/DATA5: RN7.7 (R2.2), U8.10 (DATA5)
/CONTROL Port/CONTROL PHY/DATA6: RN7.6 (R3.2), U8.11 (DATA6)
/CONTROL Port/CONTROL PHY/DATA7: RN7.5 (R4.2), U8.12 (DATA7)
/CONTROL Port/CONTROL PHY/DIR: RN5.6 (R3.2), U8.1 (DIR)
/CONTROL Port/CONTROL PHY/NXT: RN5.5 (R4.2), U8.3 (NXT)
/CONTROL Port/CONTROL PHY/PHY_D+: U8.14 (D+); also elsewhere on the board
/CONTROL Port/CONTROL PHY/PHY_D-: U8.13 (D-); also elsewhere on the board
/CONTROL Port/CONTROL PHY/RBIAS: R16.2, U8.19 (RBIAS)
/CONTROL Port/CONTROL PHY/STP: RN5.7 (R2.2), U8.24 (STP)
/CONTROL Port/CONTROL PHY/VBUS_CLAMPED: R17.1; also elsewhere on the board
/CONTROL Port/CONTROL PHY/VBUS_SENSE: R17.2, U8.17 (VBUS)
/CONTROL Port/CONTROL PHY/VDD18: C37.1, TP17.1 (1_1), U8.23 (VDD18)
/CONTROL Port/CONTROL_PHY.CLK: RN5.1 (R1.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA0: RN6.1 (R1.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA1: RN6.2 (R2.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA2: RN6.3 (R3.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA3: RN6.4 (R4.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA4: RN7.1 (R1.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA5: RN7.2 (R2.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA6: RN7.3 (R3.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DATA7: RN7.4 (R4.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.DIR: RN5.3 (R3.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.NXT: RN5.4 (R4.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.STP: RN5.2 (R2.1); also elsewhere on the board
/CONTROL Port/CONTROL_PHY.~RESET: R22.1, U8.22 (~RESET); also elsewhere on the board
GND: C36.2, C37.2, C38.2, C39.2, R16.1, R22.2, U8.25 (GND); also elsewhere on the board

Parts of its further copies:
C42, C43, C48, C50: 1uF; C_0402_1005Metric; Part Number CL05A105MQ5NNNC
C44, C46, C66, C67: 0.1uF; C_0402_1005Metric; Part Number CL05A104KA5NNNC
R18, R20: 8.06k±1%; R_0402_1005Metric; Part Number ERJ-2RKF8061X
R19, R21: 20k; R_0402_1005Metric; Part Number RC0402JR-0720KL
R23, R24: 10k; R_0402_1005Metric; Part Number RC0402JR-0710KL
RN8, RN9, RN10, RN11, RN12, RN13: 0; R_Array_Convex_4x0402; Part Number YC124-JR-070RL
TP2, TP9, TP27, TP35: TestPoint; TestPoint_Pad_D1.0mm
U9, U11: USB3343-CP; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm; Part Number USB3343-CP

Connections of its further copies:
+3V3: C42.1, C44.1, C46.1, C48.1, C66.1, C67.1, TP2.1 (1_1), TP9.1 (1_1), U9.2 (CLKOUT), U9.9 (VDDIO), U9.15 (VDD33), U9.16 (VBAT), U9.18 (ID), U11.2 (CLKOUT), U11.9 (VDDIO), U11.15 (VDD33), U11.16 (VBAT), U11.18 (ID); also elsewhere on the board
/AUX Port/AUX PHY/CLK: RN8.8 (R1.2), U11.21 (REFCLK/XI)
/AUX Port/AUX PHY/DATA0: RN9.8 (R1.2), U11.4 (DATA0)
/AUX Port/AUX PHY/DATA1: RN9.7 (R2.2), U11.5 (DATA1)
/AUX Port/AUX PHY/DATA2: RN9.6 (R3.2), U11.6 (DATA2)
/AUX Port/AUX PHY/DATA3: RN9.5 (R4.2), U11.7 (DATA3)
/AUX Port/AUX PHY/DATA4: RN10.8 (R1.2), U11.8 (DATA4)
/AUX Port/AUX PHY/DATA5: RN10.7 (R2.2), U11.10 (DATA5)
/AUX Port/AUX PHY/DATA6: RN10.6 (R3.2), U11.11 (DATA6)
/AUX Port/AUX PHY/DATA7: RN10.5 (R4.2), U11.12 (DATA7)
/AUX Port/AUX PHY/DIR: RN8.6 (R3.2), U11.1 (DIR)
/AUX Port/AUX PHY/NXT: RN8.5 (R4.2), U11.3 (NXT)
/AUX Port/AUX PHY/PHY_D+: U11.14 (D+); also elsewhere on the board
/AUX Port/AUX PHY/PHY_D-: U11.13 (D-); also elsewhere on the board
/AUX Port/AUX PHY/RBIAS: R20.2, U11.19 (RBIAS)
/AUX Port/AUX PHY/STP: RN8.7 (R2.2), U11.24 (STP)
/AUX Port/AUX PHY/VBUS_CLAMPED: R21.1; also elsewhere on the board
/AUX Port/AUX PHY/VBUS_SENSE: R21.2, U11.17 (VBUS)
/AUX Port/AUX PHY/VDD18: C50.1, TP35.1 (1_1), U11.23 (VDD18)
/AUX Port/AUX_PHY.CLK: RN8.1 (R1.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA0: RN9.1 (R1.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA1: RN9.2 (R2.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA2: RN9.3 (R3.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA3: RN9.4 (R4.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA4: RN10.1 (R1.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA5: RN10.2 (R2.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA6: RN10.3 (R3.1); also elsewhere on the board
/AUX Port/AUX_PHY.DATA7: RN10.4 (R4.1); also elsewhere on the board
/AUX Port/AUX_PHY.DIR: RN8.3 (R3.1); also elsewhere on the board
/AUX Port/AUX_PHY.NXT: RN8.4 (R4.1); also elsewhere on the board
/AUX Port/AUX_PHY.STP: RN8.2 (R2.1); also elsewhere on the board
/AUX Port/AUX_PHY.~RESET: R24.1, U11.22 (~RESET); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.CLK: RN11.1 (R1.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA0: RN12.1 (R1.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA1: RN12.2 (R2.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA2: RN12.3 (R3.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA3: RN12.4 (R4.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA4: RN13.1 (R1.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA5: RN13.2 (R2.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA6: RN13.3 (R3.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DATA7: RN13.4 (R4.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.DIR: RN11.3 (R3.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.NXT: RN11.4 (R4.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.STP: RN11.2 (R2.1); also elsewhere on the board
/FPGA Banks 6 and 7/TARGET_PHY.~RESET: R23.1, U9.22 (~RESET); also elsewhere on the board
/TARGET Port/TARGET PHY/CLK: RN11.8 (R1.2), U9.21 (REFCLK/XI)
/TARGET Port/TARGET PHY/DATA0: RN12.8 (R1.2), U9.4 (DATA0)
/TARGET Port/TARGET PHY/DATA1: RN12.7 (R2.2), U9.5 (DATA1)
/TARGET Port/TARGET PHY/DATA2: RN12.6 (R3.2), U9.6 (DATA2)
/TARGET Port/TARGET PHY/DATA3: RN12.5 (R4.2), U9.7 (DATA3)
/TARGET Port/TARGET PHY/DATA4: RN13.8 (R1.2), U9.8 (DATA4)
/TARGET Port/TARGET PHY/DATA5: RN13.7 (R2.2), U9.10 (DATA5)
/TARGET Port/TARGET PHY/DATA6: RN13.6 (R3.2), U9.11 (DATA6)
/TARGET Port/TARGET PHY/DATA7: RN13.5 (R4.2), U9.12 (DATA7)
/TARGET Port/TARGET PHY/DIR: RN11.6 (R3.2), U9.1 (DIR)
/TARGET Port/TARGET PHY/NXT: RN11.5 (R4.2), U9.3 (NXT)
/TARGET Port/TARGET PHY/PHY_D+: U9.14 (D+); also elsewhere on the board
/TARGET Port/TARGET PHY/PHY_D-: U9.13 (D-); also elsewhere on the board
/TARGET Port/TARGET PHY/RBIAS: R18.2, U9.19 (RBIAS)
/TARGET Port/TARGET PHY/STP: RN11.7 (R2.2), U9.24 (STP)
/TARGET Port/TARGET PHY/VBUS_CLAMPED: R19.1; also elsewhere on the board
/TARGET Port/TARGET PHY/VBUS_SENSE: R19.2, U9.17 (VBUS)
/TARGET Port/TARGET PHY/VDD18: C43.1, TP27.1 (1_1), U9.23 (VDD18)
GND: C42.2, C43.2, C44.2, C46.2, C48.2, C50.2, C66.2, C67.2, R18.1, R20.1, R23.2, R24.2, U9.25 (GND), U11.25 (GND); also elsewhere on the board

Schematic: type_c.kicad_sch, ${TITLE}

Parts:
C49, C58: 1uF; C_0402_1005Metric; Part Number CL05A105MQ5NNNC
C51, C63: 0.1uF; C_0402_1005Metric; Part Number CL05A104KA5NNNC
C52, C53: 330pF; C_0402_1005Metric; Part Number CL05C331JB5NNNC
R32: 0; R_0402_1005Metric; Part Number RC0402FR-070RL
R33, R38: 2.2k; R_0402_1005Metric; Part Number RC0402JR-072K2L
R39, R99: 10k; R_0402_1005Metric; Part Number RC0402JR-0710KL
TP37: TestPoint; TestPoint_Pad_D1.0mm
U12: FUSB302B; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm; Part Number FUSB302BMPX
U14: DPO2036; Diodes_UQFN2020-12_Type-B; Part Number DPO2036DBB-7

Connections:
+3V3: C49.1, C58.1, R32.2, R33.1, R38.1, R39.1, R99.1, U12.3 (VDD), U12.4 (VDD), U14.12 (VSYS); also elsewhere on the board
/AUX Port/AUX PHY/VBUS_CLAMPED: U12.2 (VBUS); also elsewhere on the board
/AUX Port/AUX Type C Controller/CC1: C52.1, U14.3 (CC1C); also elsewhere on the board
/AUX Port/AUX Type C Controller/CC1S: U12.10 (CC1), U12.11 (CC1), U14.8 (CC1S)
/AUX Port/AUX Type C Controller/CC2: C53.1, U14.4 (CC2C); also elsewhere on the board
/AUX Port/AUX Type C Controller/CC2S: U12.1 (CC2), U12.14 (CC2), U14.7 (CC2S)
/AUX Port/AUX Type C Controller/VCONN: C51.1, R32.1, TP37.1 (1_1), U12.12 (VCONN), U12.13 (VCONN)
/AUX Port/AUX_SBU1: U14.2 (SBU2C); also elsewhere on the board
/AUX Port/AUX_SBU2: U14.1 (SBU1C); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SBU1S: U14.9 (SBU2S); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SBU2S: U14.10 (SBU1S); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SCL: R38.2, U12.6 (SCL); also elsewhere on the board
/AUX Port/AUX_TYPE_C.SDA: R33.2, U12.7 (SDA); also elsewhere on the board
/AUX Port/AUX_TYPE_C.~FAULT: R99.2, U14.6 (FAULTB); also elsewhere on the board
/AUX Port/AUX_TYPE_C.~INT: R39.2, U12.5 (INT_N); also elsewhere on the board
GND: C49.2, C51.2, C52.2, C53.2, C58.2, C63.2, U12.8 (GND), U12.9 (GND), U12.15 (GND), U14.11 (GND), U14.13 (GND); also elsewhere on the board
unnamed: C63.1, U14.5 (CB)

Parts of its further copies:
C41, C56: 1uF; C_0402_1005Metric; Part Number CL05A105MQ5NNNC
C45, C57: 0.1uF; C_0402_1005Metric; Part Number CL05A104KA5NNNC
C54, C55: 330pF; C_0402_1005Metric; Part Number CL05C331JB5NNNC
R36: 0; R_0402_1005Metric; Part Number RC0402FR-070RL
R37, R100: 10k; R_0402_1005Metric; Part Number RC0402JR-0710KL
R97, R98: 2.2k; R_0402_1005Metric; Part Number RC0402JR-072K2L
TP36: TestPoint; TestPoint_Pad_D1.0mm
U2: FUSB302B; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm; Part Number FUSB302BMPX
U13: DPO2036; Diodes_UQFN2020-12_Type-B; Part Number DPO2036DBB-7

Connections of its further copies:
+3V3: C41.1, C56.1, R36.2, R37.1, R97.1, R98.1, R100.1, U2.3 (VDD), U2.4 (VDD), U13.12 (VSYS); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SBU1S: U13.10 (SBU1S); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SBU2S: U13.9 (SBU2S); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SCL: R98.2, U2.6 (SCL); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.SDA: R97.2, U2.7 (SDA); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.~FAULT: R100.2, U13.6 (FAULTB); also elsewhere on the board
/FPGA Banks 0 and 1/TARGET_C.~INT: R37.2, U2.5 (INT_N); also elsewhere on the board
/TARGET Port/TARGET PHY/VBUS_CLAMPED: U2.2 (VBUS); also elsewhere on the board
/TARGET Port/TARGET Type C Controller/CC1: C54.1, U13.3 (CC1C); also elsewhere on the board
/TARGET Port/TARGET Type C Controller/CC1S: U2.10 (CC1), U2.11 (CC1), U13.8 (CC1S)
/TARGET Port/TARGET Type C Controller/CC2: C55.1, U13.4 (CC2C); also elsewhere on the board
/TARGET Port/TARGET Type C Controller/CC2S: U2.1 (CC2), U2.14 (CC2), U13.7 (CC2S)
/TARGET Port/TARGET Type C Controller/SBU1: U13.1 (SBU1C); also elsewhere on the board
/TARGET Port/TARGET Type C Controller/SBU2: U13.2 (SBU2C); also elsewhere on the board
/TARGET Port/TARGET Type C Controller/VCONN: C45.1, R36.1, TP36.1 (1_1), U2.12 (VCONN), U2.13 (VCONN)
GND: C41.2, C45.2, C54.2, C55.2, C56.2, C57.2, U2.8 (GND), U2.9 (GND), U2.15 (GND), U13.11 (GND), U13.13 (GND); also elsewhere on the board
unnamed: C57.1, U13.5 (CB)

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright 2019-2024 Great Scott Gadgets
LICENSE: Licensed under the CERN-OHL-P v2
